# Autodesk Inventor part: Fig_2000_DN150
## iProperties
Created: 2010-12
Part Number: Fig_2000_DN150
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
